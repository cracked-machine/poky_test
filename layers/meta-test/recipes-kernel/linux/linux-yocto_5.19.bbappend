
KBRANCH:extend-qemux86-64 = "v5.19/standard/base"
KMACHINE:extend-qemux86-64 ?= "common-pc-64"
SRCREV_machine:extend-qemux86-64 ?= "23ee2ef634b3fb51be429623fa1927b1d5c3e95c"
COMPATIBLE_MACHINE:extend-qemux86-64 = "extend-qemux86-64"
LINUX_VERSION:extend-qemux86-64 = "5.19.17"
